COMPATIBLE_MACHINE = "ememu"